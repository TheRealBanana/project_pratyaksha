# Repository TheRealBanana/project_pratyaksha

File README.md:

# Project Pratyaksha
 Extra sensory perception via tactile stimulation

I was inspired by biohackers who have changed the sensory inputs their brains were receiving, showing that the brain can adapt quite well. Bicycles that turn the opposite way of the handlebars, glasses that enable you to see backwards, magnets under the finger to detect EM fields, and more. I wondered what it would be like to add some extra sense. How quickly would the brain learn to use the new information or would it just ignore the data as noise? 

The first idea I had was a simple navigation aid. A belt with 6 vibrating motors around the circumference that always vibrates in the direction of north, adding magnetoreception to our senses. There are many practical applications from helping seeing impaired individuals to a navigation aid for hikers. There's also no constraint as to the source of data being input. We could attach a software defined radio and instead buzz in the direction of certain radio signals. You could have a drone with object recognition inputting data as to the relative location of other people around you. Such a system would give an individual a real-life "spidy-sense".

It will be an interesting experiement. As of the creation of the repo its been under development for a little while (approx around the start of SensorMonitor repo) and I decided to track the progress on github.

--

May 2021 update

Here's what the first complete prototype system looks like. The belt is made from velcro material with the "buckles" self-designed and printed. Each "buckle" has a small 10mm diameter DC cellphone vibration motor glued into a matching recess. The leads from all 6 motors and a ground wire are routed out each end of the belt in 3-wire and 4-wire bundles. Each wire bundle is terminated at its end with a 6-pin header block. The main brainbox contains a custom subboard and a small atmel atmega2560 based prototyping board. The belt plugs into the subboard while the atmel controls everything. The magnetic heading data is taken from the SEN0140 10 degree-of-freedom sensor package. The magnetic heading data is corrected for tilt using the on-board IMU. The placement of the SEN0140 sensor is still undecided so its on a long lead. 

Aug 2021 update
Turns out not knowing anything about designing circuit boards came back to bite me. My current design has overcurrent issues burning traces out. I needed to add a current limiting resistor to the motor outputs (not sure why I didnt) and maybe thicker traces. Taking a break from the project for a while to concentrate on a laser projector I'm trying to design.

A pic of the v2 board that didn't work right:

## KiCad design electronics/custom_pcb_type1/custom_pcb_type1.kicad_pcb

Parts:
D1: LED_RGBC; LED_D5.0mm-4_RGB
J1: BELT_CONN_1; PinHeader_2x03_P2.54mm_Horizontal
J2: BELT_CONN_2; PinHeader_2x03_P2.54mm_Horizontal
J3: SEN0140; PinSocket_1x04_P2.54mm_Vertical
J4: USB_B; USB_B_OST_USB-B1HSxx_Horizontal
J5: JMPR_TO_ATMEGA; PinHeader_1x02_P2.54mm_Horizontal
Q1, Q2, Q3, Q4, Q5, Q6: 2N2222; TO-92_Inline
R1, R2, R3: 330; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R4, R5, R6, R7, R8, R9: 1.8K; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
RV1, RV2, RV3: 10K; Potentiometer_Runtron_RM-065_Vertical
SW1: RST_SW; SW_PUSH_6mm
U1: MEGA_PRO_EMBED_CH340G___ATMEGA2560; _ATMEGA2560; PARTREV 12/May/2017

Connections:
+5V: J4.1 (VBUS), Q1.3 (C), Q2.3 (C), Q3.3 (C), Q4.3 (C), Q5.3 (C), Q6.3 (C), RV1.1, RV2.1, RV3.1
GND: D1.2 (K), J2.4, J4.4 (GND), RV1.3, RV2.3, RV3.3, SW1.1
unnamed: D1.1 (RA), R2.2
unnamed: D1.3 (GA), R3.2
unnamed: D1.4 (BA), R1.2
unnamed: J1.1, Q1.1 (E)
unnamed: J1.4, Q2.1 (E)
unnamed: J1.5, Q3.1 (E)
unnamed: J2.2, Q4.1 (E)
unnamed: J2.3, Q5.1 (E)
unnamed: J2.6, Q6.1 (E)
unnamed: J3.1, U1.5V_1 (5V), U1.5V_2 (5V), U1.5V_3 (5V)
unnamed: J3.2, U1.GND_1 (GND), U1.GND_2 (GND), U1.GND_3 (GND)
unnamed: J3.3, U1.D21
unnamed: J3.4, U1.D20
unnamed: J4.2 (D-), J5.2
unnamed: J4.3 (D+), J5.1
unnamed: Q1.2 (B), R4.1
unnamed: Q2.2 (B), R5.1
unnamed: Q3.2 (B), R6.1
unnamed: Q4.2 (B), R7.1
unnamed: Q5.2 (B), R8.1
unnamed: Q6.2 (B), R9.1
unnamed: R1.1, U1.D45
unnamed: R2.1, U1.D46
unnamed: R3.1, U1.D44
unnamed: R4.2, U1.D4
unnamed: R5.2, U1.D2
unnamed: R6.2, U1.D3
unnamed: R7.2, U1.D5
unnamed: R8.2, U1.D7
unnamed: R9.2, U1.D9
unnamed: RV1.2, U1.A0
unnamed: RV2.2, U1.A1
unnamed: RV3.2, U1.A3
unnamed: SW1.2, U1.RST
unnamed: U1.3V3_1 (3V3), U1.3V3_2 (3V3)
unnamed: U1.VIN_1 (VIN), U1.VIN_2 (VIN)

Board: 2 copper layers, 100.3 x 69.8 mm, 25 parts (0 on the bottom side), 37 nets.

## Commit log

2021-04-14 Added ignore for subrepo
    https://github.com/TheRealBanana/SensorMonitor
    I dont know how to link a subfolder to another repo so ignoring for now.
2021-04-14 Updated wire channel cutout
    My original idea had the wires running under the belt but that bundle of wires is big enough to lift the pads away from our skin. New design is going to run the wires directly below the belt. May nee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
2021-04-17 Bigly bugs
    Got the first hardware prototype of the belt finished (barely) but when I tested it out I got a ton of random vibrating all over the place. Nothing worked right lol. They say in the military that no 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
    The very first (and probably the most severe) bug was that I was using the motorpin value as an index, which was very bad. I decided to just track the index in a variable but I'm thinking just as I t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
2021-04-18 Actual bug fix for real
    Last update was just a code review. Actually running the code on the hardware was still a hot mess. To get things sorted out I swapped the belt for 6 LEDs as an output and it made diagnosing the issu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
2021-04-19 Better PWM
    Forgot to mention in the last commit that I also changed the way the PWM values were being written because the motors were staying on after they were set to any PWM value. At first I decided to just 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
    The only two issues left I can think of atm is that the 360 degree point is actually overshooting and landing on the first motor
2021-04-20 Body interface pad changes
    Unfortunately the limitations of TPU in the printing setup I have means I can't bridge very long gaps without significant sag or even breakage (even at full 100% fan speed). That was why I had to rou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
    Instead of straight through strap routing, its now routed internally. This gives us clean access to the bottom of the pad where the wiring can be routed. The ty
2021-04-21 Filtering heading
    Realized that I didn't need to add up every heading in the buffer every time I wanted a new average, I just had to keep a sum and subtract from it the oldest value in the buffer while adding the newe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
2021-04-21 Finishing touches before magnetic data
    Holy smokes, first time I've hooked up the belt hardware to the new code and ITS AMAZING! I can totally feel like theres a seemless transition between the nodes, exactly as hoped! Now It should just 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
2021-04-21 Fully integrated stage 1
    I grafted the magnetic sensor parts of the SensorMonitor arduino code onto the circular PWM test file and this is what I got. The biggest issue right now is that the poor-mans PID works great until y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
2021-04-23 Changed test mode
    Instead of the pot controlling the angle of the output, it now controls the speed at which the output is cycled from 0-360. This mode allowed me to dial in certain parameters more easily, like the pw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
    Still have the major crashing issue with the arduino. Even just outputting the heading without any parts of the motor program is crashing eventually, which the sensormonitor app never did (or I never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
2021-04-23 Works, using mega 2560 now
    I was hoping I wouldnt have to resort to the mega because of its size but so far everything is now working great. The excess of PWM pins is a nice thing to have as well since before we had used all 6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
    One big change was to the order of the motor pins. In the old order everything was backwards with north on your back. I just moved everything over 3 slots and now its aligned properly. Besides that i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
2021-04-24 Testing a very basic fix for filtering
    I wanted to go the full PID route but decided to try and just transform the angle we were getting with a period function. I settled on tan/atan2 since it seemed like the only way to get a continuous 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
2021-04-24 Atan2 averaged Filtering
    Applied the same solution to the belt code and all seems to be working fine. Ran into another crash however. It seems I forgot to hook up the ground all the motors were using but somehow they were st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
2021-04-24 Enable PWM max tuning
    Added in the ability to tune the max output of the motors via the potentiometer at A0.
2021-04-25 Fixed bug in heading filter
    Fixed a major bug where the cosine parts of the filter were actually being fed sine data. It kind of sort of actually worked even with the bug but the weird issues I was having are seemingly just thi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
    Next up for the project is miniaturizing this whole thing so I can start walking around with it full time. I bought an $11 "AITRIP Mega 2560 Pro Embed". Its a tiny (3.8cm x 5.5cm) atmega2560 board wi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
2021-05-01 First hardware prototype
    Finished soldering up the first hardware prototype and it seems like it actually worked on the first try! That like almost never happens lol, I usually end up resolding one or two things. I made doub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
    The first instinct is just to put the sensor on the same board as everything else and jam it in our pocket. Thing is, our tilt compensation aint the greatest so the random orientation in our pocket p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
2021-05-06 Added corrections for sensor heading misalignment
    First trials with the prototype hardware I found immediately that I had to have the sensor perfectly aligned with my body for the whole thing to work properly. This correction offset will fix that. A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
2021-05-06 Brainbox CAD
    Starting work on the brainbox to hold everything and Ive got the two boards basically mocked up. Now will build the case around it.
2021-05-07 Sub-board brainbox half started
    Got the side of the case holding the sub board basically designed. Got most of the way complete when I realized there was no space for case screw holes so I had to improvise with the bulbs on the cor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
2021-05-07 Case v1 finished
    got the very basics finished, its a couple pieces of plastic that should contain both PCBs and their wires nicely. It has no provisions for buttons, status leds, or anything like that. This is bare b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
    Not near a 3D printer atm so will have to wait a day before I can print this out.
2021-05-10 Software adaptations to hardware limitations
    Decided just to leave the current hardware alone and use it for a while. To that end instead of a status LED I decided to use vibration patterns instead. 2 slow buzzes means calibration has started, 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
2021-05-10 Update README.md
    Added further details about the device construction and a picture of the final prototype system.
2021-05-10 fat fingered it
    yeap
2021-05-10 Actually set compass offset
    Forgot to actually set the compass offset. Also fixed the buzzing indicator to actually work instead of blurring all individual buzzes into one long buzz.
2021-05-13 Starting work on custom PCB
    I'm tired of making PCBs by hand using crappy protoboard and the constraints it brings. I have a laser printer and a drill already so with just some ferric chloride and raw PCB blanks I should be abl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
    Also added 2 new potentiometers to the circuit so I had to add new references in the arduino code. The variable names are now perfectly descriptive.
2021-05-13 Added USB connector
    I'm pulling power from a secondary USB port on my prototype board and I plan to do the same here. The +5V from the USB port is used directly by everything and is passed to the atmega through its usb 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
2021-05-13 Physical PCB start
    Sort of got a start on the physical PCB layout. Its hard to lay things out in ways that don't overlap with other traces on a single layer. I got most of everything connected up and I think what I hav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
2021-05-13 Better PCB routing
    Before I started doing the back side routing I decided to try rerouting things for more traces on the top layer. I ended up changing the pinout to use even numbered pins 2-12 backwards (i.e. first mo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
2021-05-14 PCB version 1.0
    Ok I've finished laying everything out. In the end I was successful in laying out the data and power traces on top and only have ground traces on the bottom. I've generated the reversed masks that ar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
2021-05-14 Cleaned up traces
    Looking at the mask I saw a couple spots where It was questionable if it would etch properly. I just separated out the traces the best I could. I'm wondering if I could remove the unused pins of the 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
2021-05-15 Size matters
    Welp Got all the way to putting the transfer paper onto the PCB when I found out that my raw PCBs are kinda small. 70mm x 100mm - which is a lot smaller than the current footprint of like 90mm x 120m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
2021-05-15 Forgot some text
    Forgot the text I added to identify the board and version. It should be nicely visible even after all components are on the board.
2021-05-24 Moved some traces
    Finally got around to trying to make the PCB and it actually went fairly well. My first try had something mostly workable, just a few traces that bridged here and there. Probably just improper techni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
    With this first board I was only interested in the processes and not the final product so I didnt attempt to protect the back from etching. I realized theres only like 4 or 5 ground connections anywa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
2021-05-24 D+ trace move
    D+ ran a bit close to the GND pad of the USB connector. It didnt bridge in my first PCB but Its easy enough to move a little and avoid any problems in the future.
2021-05-28 Rerouting to be single-sided
    Since I can't plate my through-holes, any connections on the opposite side of the board had to be soldered too. The problem there is that the components are in the way so you can't solder. Because of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
    Also didn't realize I forgot to connect one of the pins for the SEN0140 board. I guess I deleted
2021-06-02 Adjustments for new PCB design
    The final custom PCB changed some of the pins to make trace routing easier. In addition to updating those pin numbers, I switched the order of motors in MOTORS[] to be sequential instead of the right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
2021-06-03 Brainbox type2
    Start of work for the type2 brainbox that is for our custom PCB. Atm I only have the board mockup and a support for the SEN0140 board.
2021-06-09 Case bottom finished
    Finished working on the bottom part of the case. As soon as it finished printing and the fitment is good I will design the top half.
2021-08-24 Updated readme and changed to public
    Taking a break from this project for a little while so I figured I would make it public. Most of the work is done. The code is a little shaky in terms of stability (and I'm not a C coder so its not s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
    I'm considering maybe switching from cellphone vibration motors to direct current stimulation of the skin. I have a TENS device for an old injury that got me thinking how it could be repurposed for t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
2021-08-24 Added v2 PCB pic
    The V2 PCB is rather nice to look at so I went ahead and added a pic to the front page. It may not have worked, but damn it looks good imo.
